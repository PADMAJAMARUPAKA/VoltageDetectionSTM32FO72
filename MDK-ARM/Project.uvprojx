# Keil uVision project Project.uvprojx, settings and files
target STM32F072B-Discovery (5060960::V5.06 update 7 (build 960)::.\Arm3)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F072B-Discovery
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=5 wLevel=2
  c define: STM32F072xB,USE_HAL_DRIVER,USE_STM32F072B_DISCO
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32F072B-Discovery;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Utilities\Log;..\..\..\..\..\..\Utilities\CPU;..\Inc\RTOS;..\Inc\watchdog;..\Inc\adc;..\Inc\spi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Example/MDK-ARM
    ./: startup_stm32f072xb.s
  group Drivers/CMSIS
    ../Src/startup/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Src/hal/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/startup/: main.c
    ../Src/hal/: stm32f0xx_it.c
  group Drivers/BSP/STM32F072B-Discovery
    ../Src/startup/: stm32f072b_discovery.c
  group FreeRTOS
    ../Src/rtos/: list.c queue.c tasks.c timers.c event_groups.c port.c tasks_list.c
  group Watchdog
    ../Src/watchdog/: watchdog.c
  group LED
    ../Src/led/: led.c
  group adc
    ../Src/adc/: adc.c
  group spi
    ../Src/spi/: spi.c
software components: CMSIS:CORE 5.6.0, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0
